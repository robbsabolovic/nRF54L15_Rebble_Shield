# Repository robbsabolovic/nRF54L15_Rebble_Shield

File README.md:

# nRF54L15-DK Rebble Shield - SMD

---
KiCAD PCB template with Bottom SMD header connection to nRF54L15-DK.  
Intended to support Rebble contestants on [Hackster.io](https://Hackster.io)

This KiCAD Template simplifies initial setup for creating an nRF54L15-DK Shield PCB designs.<br>
To begin, clone this repository to your KICAD_USER_TEMPLATE_DIR as found under "Preferences > Configure Paths..."<br>
Next, use "File > New Project from Template..." or "Ctrl+T" and select "User Templates." Select the template and begin!

## KiCad design nRF54L15_Rebble_Shield.kicad_pcb

Board: 4 copper layers, 8 parts (1 on the bottom side), 3 nets.

Parts:
G**: Nordic Logo; NORDIC_LOGO_LYING
G**#2: Nordic Logo; NORDIC_LOGO_LYING
P0, P1, P2: Pin Hdr 2x10; HDR_2x10-SMD_BTM
P30, P31, P32: Pin Header 2x2 SMD; HDR_2x2-SMD_BTM

Connections:
GND: P0.2, P0.19, P1.2, P1.19, P2.2, P2.19, P30.2, P30.4, P31.2, P31.4, P32.2, P32.4
VBUS: P30.1, P31.1, P32.1
VDDIO: P0.1, P0.20, P1.1, P1.20, P2.1, P2.20
